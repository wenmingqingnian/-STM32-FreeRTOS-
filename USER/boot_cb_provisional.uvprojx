# Keil uVision project boot_cb_provisional.uvprojx, settings and files
target Boot_CB_Provisional (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x3800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: D:\Keilv5\ARM\ARMCC\Bin\fromelf.exe --bin -o ..\OBJ_BOOT_PROV\boot.bin ..\OBJ_BOOT_PROV\boot.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\CONFIG;..\BOOT;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\IAP;..\BSP\CRC32;..\BSP\LOWPOWER
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0xC000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group BOOT_SYSTEM
    ./: system_stm32f10x.c
  group BOOT
    ../BOOT/: boot_main.c boot_request.c boot_uart_dma.c boot_update.c boot_protocol.c boot_flash.c boot_image.c boot_jump.s
  group BSP_IAP
    ../BSP/IAP/: iap_meta.c
    ../BSP/CRC32/: crc32.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
