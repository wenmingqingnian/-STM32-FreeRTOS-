# Keil uVision project app_audit.uvprojx, settings and files
target App_SlotA_SizeAudit (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08003800,0x1DC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: range_hood_app_slot_a +hex
  AfterMake: D:\Keilv5\ARM\ARMCC\Bin\fromelf.exe --bin -o ..\OBJ_APP_AUDIT\range_hood_app.bin ..\OBJ_APP_AUDIT\range_hood_app.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,VECT_TAB_OFFSET=0x00003800
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\BSP\BEEP;..\BSP\DHT11;..\BSP\DMA;..\BSP\EXTI;..\BSP\IAP;..\BSP\KEY;..\BSP\LCD;..\BSP\SPI;..\BSP\STMFLASH;..\BSP\MOTOR;..\BSP\GPIO;..\BSP\PID;..\BSP\MQ2;..\BSP\WIND;..\APP_TASK;..\BSP\KEY;..\BSP\CRC32;..\BSP\DIAG;..\BSP\RESET;..\BSP\WATCHDOG;..\CONFIG;..\BOOT;..\BSP\LOWPOWER
  memory RVCT4: ROM 0x8003800 size 0x1DC00
  memory RVCT9: RAM 0x20000000 size 0xC000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/DHT11/: dht11.c
    ../BSP/BEEP/: beep.c
    ../BSP/IAP/: iap_request.c
    ../BSP/LOWPOWER/: lowpower.c lowpower_policy.c lowpower_math.c rtc_timebase.c exti_stop_backend.c system_clock_resume.c
    ../BSP/LCD/: GUI.c lcd.c
    ../BSP/SPI/: SPI.c
    ../BSP/MOTOR/: motor.c
    ../BSP/GPIO/: gpiox.c
    ../BSP/PID/: pid.c
    ../BSP/MQ2/: mq2.c
    ../BSP/WIND/: wind_speed.c
    ../BSP/KEY/: key.c key_exti.c
    ../BSP/CRC32/: crc32.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c stm32f10x_bkp.c stm32f10x_pwr.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group app_task
    ../APP_TASK/: app_tasks.c task_health.c standby_policy.c fault_decision.c
  group BSP_DIAG
    ../BSP/DIAG/: dwt_profiler.c prio_inversion.c
  group BSP_RESET
    ../BSP/RESET/: reset_cause.c
  group BSP_WATCHDOG
    ../BSP/WATCHDOG/: watchdog.c
target App_SlotB_SizeAudit (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08021400,0x1DC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: range_hood_app_slot_b +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,VECT_TAB_OFFSET=0x00021400
  c include: as above
  memory RVCT4: ROM 0x8021400 size 0x1DC00
  memory RVCT9: RAM 0x20000000 size 0xC000
